SRC_URI = "git://github.com/dlenski/PySIMG.git;protocol=https;nobranch=1"
