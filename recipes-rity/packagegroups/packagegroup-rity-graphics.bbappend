RDEPENDS:${PN}:remove:osm-mtk520 = "opengl-es-cts vulkan-cts"
