FILESEXTRAPATHS:prepend:absolute-vision := "${THISDIR}/absolute-vision:"
