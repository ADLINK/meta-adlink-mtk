FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
       file://0001-tools-mtk_image-Fix-UFS-image-header-checking-failur.patch \
"



