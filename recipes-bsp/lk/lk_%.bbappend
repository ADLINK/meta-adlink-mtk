FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:lec-mtk-i1200-qspi = " ${LK_SRC_PATCHES} "



